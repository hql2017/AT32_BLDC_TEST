# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413RCT7_v2 ArteryTek -AT32F413RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f413_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32f413_board/: at32f413_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f413.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group firmware
    ../../../../libraries/drivers/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f413_clock.c at32f413_int.c main.c
