# IAR project bootloader.ewp, settings and files
configuration bootloader (ARM)
  General.OGChipSelectEditMenu: AT32F413RCT7_v2 ArteryTek -AT32F413RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413RCT7; USE_STDPERIPH_DRIVER; AT_START_F413_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f413_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: AT32F413xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f413_board/: at32f413_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f413.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f413_crm.c at32f413_flash.c at32f413_gpio.c at32f413_misc.c at32f413_tmr.c at32f413_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f413_clock.c at32f413_int.c flash.c iap.c main.c tmr.c usart.c
