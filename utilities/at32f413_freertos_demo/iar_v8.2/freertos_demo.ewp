# IAR project freertos_demo.ewp, settings and files
configuration at_start_f413 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413RCT7_v2 ArteryTek -AT32F413RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT_START_F413_V1; AT32F413RCT7
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc; ..\..\..\project\at32f413_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../project/at32f413_board/: at32f413_board.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f413.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
  group firmware
    ../../../libraries/drivers/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: at32f413_clock.c at32f413_int.c main.c
